# Keil uVision project RTOS LABS.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RTOS LABS
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: Main.c
software components: RTOS:Config 10.2.0, RTOS:Core 10.2.0, RTOS:Coroutines 10.2.0, RTOS:Event Groups 10.2.0, RTOS:Heap 10.2.0, RTOS:Message Buffer 10.2.0, RTOS:Stream Buffer 10.2.0, RTOS:Timers 10.2.0, CMSIS:CORE 5.3.0, CMSIS:DSP 1.7.0, CMSIS:NN Lib 1.2.0, CMSIS:RTOS2:Keil RTX5 5.5.1, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0
